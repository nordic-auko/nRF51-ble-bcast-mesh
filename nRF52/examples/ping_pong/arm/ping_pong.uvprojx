# Keil uVision project ping_pong.uvprojx, settings and files
target ping_pong (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ping_pong +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S132 BOARD_PCA10040 SOFTDEVICE_PRESENT NRF52 PACKET_STATS DEBUG
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\RTT;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\uart
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20004000 size 0xc000
  link misc: --callgraph
  group app
    ../: main.c cmd_if.c
  group rbc_mesh
    ../../../rbc_mesh/src/: rbc_mesh.c radio_control.c timer_control.c timeslot_handler.c trickle.c mesh_gatt.c transport_control.c fifo.c event_handler.c version_handler.c mesh_packet.c bootloader_info_app.c bootloader_app.c bootloader_util.c rand.c handle_storage.c
  group lib
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/libraries/util/: app_error.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.6.0
